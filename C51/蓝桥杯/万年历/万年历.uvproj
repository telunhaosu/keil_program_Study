# Keil uVision project 万年历.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 万年历 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\Main
  group Source Group 1
    ./: STARTUP.A51
  group Main
    ./Main/: main.c Sys.h
  group Hardware
    ./Hardware/: DS1302.c DS1302.h Delay.c Delay.h DS18B20.c DS18B20.h NixieTupe.c NixieTupe.h
